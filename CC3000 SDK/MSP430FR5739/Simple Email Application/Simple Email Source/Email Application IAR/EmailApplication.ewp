# IAR project EmailApplication.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 334
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\Source\CC3000HostDriver; ..\Source\HyperTerminal Driver; ..\Source\CC3000 Spi; ..\Source\inc; ..\Source\Simplemail\inc
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  A430.AUserIncludes: as above
  XLINK.XclFile: EmailApplication_lnk430fr5739.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../Source/Simplemail/: board.c cc3000.c demo.c smtp.c
  group Library
    Debug/Exe/: CC3000 Host Driver.r43 CC3000_Spi.r43 HyperTerminalDriver.r43
