# IAR project CC3000 Automation App.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 240
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\source\CC3000HostDriver; ..\source\Automation App; ..\source\Board; ..\source\inc
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: vee_lnk430fr5739.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../source/Board/: board.c board.h
    ../source/Automation App/: cc3000.c cc3000.h common.h config_defs.h demo.c demo_config.h sensors.c sensors.h server.c server.h strlib.c strlib.h terminal.c terminal.h uart.c uart.h version.h
  group Library
    Debug/Exe/: CC3000 Host Driver.r43 CC3000_Spi.r43
