# IAR project CC3000 Home Automation.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 240
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\source\CC3000HostDriver; ..\source\Board Config; ..\source\inc; ..\source\DemoApp; ..\source\DemoApp\cosm; ..\source\DemoApp\fram_sensors; ..\source\DemoApp\strlib
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: vee_lnk430fr5739.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../source/Board Config/: board.c board.h
    ../source/DemoApp/: cc3000.c cc3000.h common.h config_defs.h demo.c demo_config.h
    ../source/DemoApp/cosm/: cosm.c cosm.h
    ../source/DemoApp/fram_sensors/: sensors.c sensors.h
    ../source/DemoApp/strlib/: strlib.c strlib.h
  group Library
    Debug/Exe/: CC3000 Host Driver.r43 CC3000_Spi.r43
