# IAR project CC3000Spi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; TARGET_IS_BLIZZARD_RA1; PART_LM4F232H5QD
  ICCARM.CCIncludePath2: ..; ..\Source\cc3000_spi\inc; ..\Source\cc3000_host_driver\core_driver\inc; ..\Source\cc3000_host_driver\include\common; C:\StellarisWare
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: CC3000Spi.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Source/cc3000_spi/src/: spi.c
