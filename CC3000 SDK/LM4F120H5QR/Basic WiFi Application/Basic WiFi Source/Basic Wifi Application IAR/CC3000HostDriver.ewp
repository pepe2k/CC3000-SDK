# IAR project CC3000HostDriver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM4F232H5QD; TARGET_IS_TEMPEST_RC1
  ICCARM.CCIncludePath2: ..; ..\Source\cc3000_host_driver\include\common; ..\Source\cc3000_host_driver\core_driver\inc; ..\Source\cc3000_spi\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: driver.srec
  ILINK.IlinkOutputFile: driver.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group Source
    ../Source/cc3000_host_driver/core_driver/src/: cc3000_common.c evnt_handler.c hci.c netapp.c nvmem.c security.c socket.c wlan.c
