# IAR project TinyWebServer.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 1
  ICC430.newCCIncludePaths: .; ..\Source\inc; ..\Source\CC3000 Spi; ..\Source\CC3000HostDriver; ..\Source\WebServer Application\; ..\Source\MD5; ..\Source\Board; ..\Source\Hyper Terminal Driver
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430f5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../Source/WebServer Application/: cc3000.c FlashDB.c FlashDbContent.c HttpAuth.c HttpCore.c HttpDebug.c HttpDynamic.c HttpDynamicHandler.c HttpStatic.c HttpString.c WebServerApp.c
    ./: low_level_init.c
  group Board
    ../Source/Board/: board.c Wheel.c
  group HyperTerminal
    ../Source/Hyper Terminal Driver/: dispatcher.c
  group Library
    Debug/Exe/: CC3000HostDriver.r43 CC3000Spi.r43
  group MD5
    ../Source/MD5/: md5.c
