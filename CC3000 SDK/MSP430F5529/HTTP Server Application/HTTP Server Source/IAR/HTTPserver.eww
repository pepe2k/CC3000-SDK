<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CC3000HostDriver.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CC3000Spi.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TinyWebServer.ewp</path>
  </project>
  <batchBuild/>
</workspace>


