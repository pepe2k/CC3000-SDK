# IAR project Hyper Terminal Driver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F232H5QD TexasInstruments LM4F232H5QD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; TARGET_IS_BLIZZARD_RA1; PART_LM4F232H5QD; USE_UART_DMA
  ICCARM.CCIncludePath2: ..; ..\Source\inc; ..\Source\CC3000HostDriver; C:\StellarisWare
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: Backup of Hyper Terminal Driver.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Source
    ../Source/HyperTerminal Driver/: dispatcher.c
