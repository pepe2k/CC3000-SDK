# IAR project BasicWiFiApplication.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F232H5QD TexasInstruments LM4F232H5QD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM4F232H5QD; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCIncludePath2: .; ..\Source\inc; ..\Source\HyperTerminal Driver\.; ..\Source\CC3000 Spi\.; ..\Source\CC3000HostDriver\.; C:\StellarisWare\; C:\StellarisWare\driverlib\; C:\StellarisWare\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BasicWiFiApplication.bin
  ILINK.IlinkOutputFile: Example Application.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Example Application.srec
  group Libraries
    Debug/Exe/: CC3000HostDriver.a CC3000Spi.a Hyper Terminal Driver.a
    C:/StellarisWare/driverlib/ewarm-cm4f/Exe/: driverlib-cm4f.a
  group Source
    ../Source/Basic Wifi Application/: basic_wifi_application.c board.c
    ./: startup_ewarm.c
